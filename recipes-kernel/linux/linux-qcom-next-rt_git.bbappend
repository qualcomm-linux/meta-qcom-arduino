require linux-qcom-next-arduino.inc
